# Keil uVision project project.uvprojx, settings and files
target oneos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, OS_TASK_SWITCH_NOTIFY, USE_HAL_DRIVER
  c include: .;application;application;application\atk_key;application\atk_lcd;..\..\arch\arm\armv7m\include;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\components\cJSON-v1.7.12;..\..\components\ota\cmiot\inc;..\..\common\include;..\..\components\diagnose\cpu_moniter;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\drivers;..\..\drivers\boot\cotex-m;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\eeprom;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\sflash;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\graphic\font;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\hal\st\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\security\mbedtls\mbedtls-v2.16.8\include;..\..\components\security\mbedtls\mbedtls-v2.16.8\include\mbedtls;..\..\components\security\mbedtls\port\inc;..\..\components\net\molink\api\include;..\..\components\net\molink\core\include;..\..\components\net\molink\module\esp8266\include;..\..\components\net\molink\parser\include;..\..\components\cloud\onenet\mqtt-kit\authorization;..\..\components\cloud\onenet\mqtt-kit\cert;..\..\components\cloud\onenet\mqtt-kit\mqtts_device;..\..\components\position;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\gnss_pos\rtk;..\..\components\position\net_pos;..\..\components\net\protocols\mqtt\pahomqtt-v1.1.0\MQTTPacket\src;..\..\components\net\protocols\mqtt\pahomqtt-v1.1.0\MQTTClient-OneOS\src;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\net\socket\include;..\..\components\net\socket\include\sys_socket;..\..\components\diagnose\stack_trace;..\..\components\net\protocols\websocket;..\..\components\net\protocols\websocket\api\client\include
  asm define: OS_TASK_SWITCH_NOTIFY
  library: MicroLIB
  memory RVCT4: ROM 0x8009000 size 0x6f000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: RC522.c main.c my_device.c
    application/atk_key/: atk_key.c
    application/atk_lcd/: atk_lcd.c
  group arch
    ../../arch/arm/armv7m/: arch_atomic.c arch_exception.c arch_interrupt.c arch_misc.c arch_task.c
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f1xx_hal_msp.c stm32f1xx_it_bsp.c system_stm32f1xx.c
    board/startup/: startup_stm32f103xe_arm.s
  group cjson
    ../../components/cJSON-v1.7.12/: cJSON.c cJSON_Utils.c cJSON_port.c
  group cmiot
    ../../components/ota/cmiot/src/: cmiot_self.c cmiot_user.c
  group cmiotlib
    ../../components/ota/cmiot/lib/single/gen/: arm_cortex-m3_cmiot_fota.lib
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/backend/: console_backend.c
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/syslog/: syslog.c
  group drivers
    ../../drivers/misc/: adc.c dac.c pulse_encoder.c push_button.c pwm.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/timer/: clockevent.c clocksource.c clocksource_cortexm.c hrtimer.c timer.c
    ../../drivers/console/: console.c
    ../../drivers/: device.c driver.c
    ../../drivers/dma/: dma_ram.c soft_dma.c
    ../../drivers/eeprom/: eeprom.c eeprom_info.c
    ../../drivers/fal/: fal.c fal_block.c fal_mtd.c fal_part.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/sflash/: sfbus.c sfdp.c sfdp_basic.c sflash.c sflash_info.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/boot/cotex-m/: vector_table.c
    ../../drivers/watchdog/: watchdog.c
  group font
    ../../drivers/graphic/font/: font_asc2_1608.c font_asc2_2412.c font_asc2_3216.c
  group graphic
    ../../drivers/graphic/: atk_tflcd9341.c graphic.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_adc.c drv_can.c drv_common.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_iwdg.c drv_pulse_encoder.c drv_pwm.c drv_rtc.c drv_spi.c drv_sram.c drv_usart.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_f1.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_spi.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group mbedtls
    ../../components/security/mbedtls/mbedtls-v2.16.8/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../components/security/mbedtls/port/src/: entropy_hardware_alt.c net_sockets.c timing_alt.c
  group molink
    ../../components/net/molink/parser/source/: at_parser.c at_printf.c at_resp.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_ifconfig.c esp8266_netconn.c esp8266_ping.c esp8266_wifi.c
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_ifconfig.c mo_netconn.c mo_ping.c mo_socket.c mo_wifi.c
    ../../components/net/molink/core/source/: mo_ipaddr.c mo_lib.c mo_object.c mo_time.c
  group onenet
    ../../components/cloud/onenet/mqtt-kit/cert/: ca_certificate.c
    ../../components/cloud/onenet/mqtt-kit/authorization/: hmac_sha1.c onenet_base64.c token.c
    ../../components/cloud/onenet/mqtt-kit/mqtts_device/: onenet_mqtts.c
  group pahomqtt
    ../../components/net/protocols/mqtt/pahomqtt-v1.1.0/MQTTClient-OneOS/src/: MQTTClient.c MQTTOneOS.c
    ../../components/net/protocols/mqtt/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group sensors
    ../../drivers/sensors/: aht10.c photo_diode.c sensor.c
  group socket
    ../../components/net/socket/source/: socket.c
  group websocket
    ../../components/net/protocols/websocket/thirdpart/polarssl/src/: sha1.c
    ../../components/net/protocols/websocket/api/client/source/: ws_client.c
    ../../components/net/protocols/websocket/app/source/: ws_client_app.c
    ../../components/net/protocols/websocket/core/source/: ws_client_core.c ws_common.c
